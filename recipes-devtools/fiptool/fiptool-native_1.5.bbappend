SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-components/atf;protocol=https;nobranch=1 \
          "
SRCREV = "4a82c939a0211196e2b80a495f966383803753bb"
